#SYSVINIT_ENABLED_GETTYS = "S0"
